# Keil uVision project TOF.uvprojx, settings and files
target TOF (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TOF +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\VL53L0X\platform\inc;..\VL53L0X\core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: i2c.c delay.c ads7924.c main.c gpio.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c report.c task_launch.c vl53l0x.c
  group vl53l0x
    ../VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ../VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group uC-BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group uC-CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group uC-LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC-CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC-PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s os_cpu.h
  group uC-CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
software components: CMSIS:CORE 4.3.0
